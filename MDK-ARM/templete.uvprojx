# Keil uVision project templete.uvprojx, settings and files
target templete (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: templete +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,LV_LVGL_H_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\BSP;..\SYSTEM;..\User\Tasks;..\LVGL\src;..\LVGL\examples\porting;..\LVGL;..\User\MiddleLayer;..\User\GUI;..\User\GUI\custom;..\User\GUI\generated;..\User\GUI\generated\guider_customer_fonts;..\User\GUI\generated\images
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/Task
    ../User/Tasks/: HardwareInitTask.c HardwareInitTask.h TaskInit.c TaskInit.h KeyTask.c KeyTask.h ScrRenewTask.h ScrRenewTask.c SensorUpdateTask.c SensorUpdateTask.h RunMode.c RunMode.h
  group Application/User/System
    ../SYSTEM/: delay.c delay.h sys.h
  group Application/User/MiddleLay
    ../User/MiddleLayer/: HWDataAccess.c HWDataAccess.h PageManager.c PageManager.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/BSP
    ../BSP/: LCD.c LCD.h LCDfont.h WDOG.c WDOG.h Power.c Power.h CST816.c CST816.h key.c key.h MyI2C.c MyI2C.h AHT21.c AHT21.h SPL06_001.c SPL06_001.h LSM303.c LSM303.h em70x8.h em70x8.c user_Queue.c user_Queue.h HrAlgorythm.c HrAlgorythm.h mpu6050.c mpu6050.h dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group LVGL_myLVGL
    ../User/GUI/custom/: custom.c custom.h lv_conf_ext.h
    ../User/GUI/generated/: events_init.c events_init.h gui_guider.c gui_guider.h setup_scr_Calculater.c setup_scr_Calender.c setup_scr_Compass.c setup_scr_Environment.c setup_scr_Game.c setup_scr_Heart.c setup_scr_Home.c setup_scr_Menu.c setup_scr_PowerOff.c setup_scr_SetDate.c setup_scr_SetDateTime.c setup_scr_SetLightTime.c setup_scr_SetOffTime.c setup_scr_SetTime.c setup_scr_Setting.c setup_scr_Stopwatch.c widgets_init.c widgets_init.h
    ../User/GUI/generated/guider_customer_fonts/: guider_customer_fonts.h lv_font_montserratMedium_12.c lv_font_montserratMedium_30.c lv_font_montserratMedium_50.c lv_font_montserratMedium_25.c lv_font_montserratMedium_20.c
    ../User/GUI/generated/images/: _1_alpha_25x25.c _1_alpha_30x30.c _2_alpha_25x25.c _3_alpha_30x30.c _4_alpha_30x30.c _5_alpha_30x30.c _6_alpha_30x30.c _7_alpha_25x25.c _7_alpha_30x30.c _8_alpha_30x30.c _9_alpha_30x30.c _10_alpha_30x30.c _11_alpha_30x30.c _12_alpha_25x25.c _altitude_alpha_30x30.c _battery_alpha_20x20.c _blueteeth_alpha_25x25.c _confirm_alpha_30x30.c _DateSet_alpha_30x30.c _dotdot_alpha_20x20.c _needle_alpha_30x70.c _power_alpha_25x25.c _power_alpha_40x40.c _reset_30x30.c _setting_alpha_25x25.c _setting_alpha_30x30.c _start_alpha_30x30.c _start1_alpha_30x30.c _stop_alpha_30x30.c _stop1_alpha_30x30.c _TurnOff_alpha_30x30.c _TurnOn_alpha_30x30.c _Wrist_alpha_30x30.c
  group LVGL_conf
    ../LVGL/: lv_conf.h lvgl.h
  group LVGL_porting
    ../LVGL/examples/porting/: lv_port_disp.c lv_port_fs.c lv_port_indev.c lv_port_indev.h
  group LVGL_src
    ../LVGL/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
    ../LVGL/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
    ../LVGL/src/draw/: lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_layer.c lv_draw_layer.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_transform.c lv_draw_transform.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h lv_draw.c lv_draw.h
    ../LVGL/src/draw/arm2d/: lv_gpu_arm2d.c lv_gpu_arm2d.h
    ../LVGL/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp.h lv_draw_pxp_blend.c lv_draw_pxp_blend.h lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h
    ../LVGL/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite.h lv_draw_vglite_arc.c lv_draw_vglite_arc.h lv_draw_vglite_blend.c lv_draw_vglite_blend.h lv_draw_vglite_line.c lv_draw_vglite_line.h lv_draw_vglite_rect.c lv_draw_vglite_rect.h lv_vglite_buf.c lv_vglite_buf.h lv_vglite_utils.c lv_vglite_utils.h
    ../LVGL/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c lv_gpu_d2_ra6m3.h
    ../LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_layer.h lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h
    ../LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
    ../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c lv_gpu_swm341_dma2d.h
    ../LVGL/src/extra/: lv_extra.c lv_extra.h
    ../LVGL/src/extra/layouts/flex/: lv_flex.c lv_flex.h
    ../LVGL/src/extra/layouts/grid/: lv_grid.c lv_grid.h
    ../LVGL/src/extra/layouts/: lv_layouts.h
    ../LVGL/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
    ../LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
    ../LVGL/src/extra/libs/freetype/: lv_freetype.c lv_freetype.h
    ../LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
    ../LVGL/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
    ../LVGL/src/extra/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
    ../LVGL/src/extra/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.c qrcodegen.h
    ../LVGL/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.h
    ../LVGL/src/extra/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
    ../LVGL/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c lv_tiny_ttf.h stb_rect_pack.h stb_truetype_htcw.h
    ../LVGL/src/extra/libs/: lv_libs.h
    ../LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c
    ../LVGL/src/extra/others/gridnav/: lv_gridnav.c lv_gridnav.h
    ../LVGL/src/extra/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h
    ../LVGL/src/extra/others/imgfont/: lv_imgfont.c lv_imgfont.h
    ../LVGL/src/extra/others/monkey/: lv_monkey.c lv_monkey.h
    ../LVGL/src/extra/others/msg/: lv_msg.c lv_msg.h
    ../LVGL/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
    ../LVGL/src/extra/others/: lv_others.h
    ../LVGL/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
    ../LVGL/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
    ../LVGL/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
    ../LVGL/src/extra/themes/: lv_themes.h
    ../LVGL/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
    ../LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
    ../LVGL/src/extra/widgets/chart/: lv_chart.c lv_chart.h
    ../LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
    ../LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
    ../LVGL/src/extra/widgets/keyboard/: lv_keyboard.c lv_keyboard.h
    ../LVGL/src/extra/widgets/led/: lv_led.c lv_led.h
    ../LVGL/src/extra/widgets/list/: lv_list.c lv_list.h
    ../LVGL/src/extra/widgets/menu/: lv_menu.c lv_menu.h
    ../LVGL/src/extra/widgets/meter/: lv_meter.c lv_meter.h
    ../LVGL/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
    ../LVGL/src/extra/widgets/span/: lv_span.c lv_span.h
    ../LVGL/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
    ../LVGL/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
    ../LVGL/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
    ../LVGL/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
    ../LVGL/src/extra/widgets/win/: lv_win.c lv_win.h
    ../LVGL/src/extra/widgets/: lv_widgets.h
    ../LVGL/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_symbol_def.h
    ../LVGL/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
    ../LVGL/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
    ../LVGL/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
software components: CMSIS:CORE 4.3.0
